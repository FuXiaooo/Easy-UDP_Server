# Keil uVision project NET_LWIP.uvprojx, settings and files
target NET_LWIP (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: NET_LWIP +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: E:\50-network;..\USER;..\FWLIB\STM32F10x_FWLib;..\USMART;..\HARDWARE\BEEP;..\HARDWARE\DM9000;..\HARDWARE\ITEMP;..\HARDWARE\KEY;..\HARDWARE\LCD;..\HARDWARE\LED;..\HARDWARE\RTC;..\HARDWARE\SRAM;..\HARDWARE\TIMER;..\CORE;..\MALLOC;..\SYSTEM;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\FWLIB\STM32F10x_FWLib\src;..\FWLIB\STM32F10x_FWLib\inc;..\LWIP;..\LWIP\api;..\LWIP\core;..\LWIP\include;..\LWIP\netif;..\LWIP\include;..\LWIP\include\compat;..\LWIP\include\lwip;..\LWIP\include\netif;..\LWIP\arch;..\LWIP\core\ipv4;..\LWIP\include\compat\posix;..\LWIP\include\compat\stdc;..\LWIP\include\netif\ppp;..\LWIP\My_demo;..\LWIP\My_demo\inc;..\LWIP\My_demo\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/SRAM/: sram.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/DM9000/: dm9000.c
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/RTC/: rtc.c
    ../HARDWARE/ITEMP/: tsensor.c
  group FWLIB
    ../FWLIB/STM32F10x_FWLib/src/: misc.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_exti.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_pwr.c stm32f10x_rtc.c
  group MALLOC
    ../MALLOC/: malloc.c
  group USMART
    ../USMART/: usmart.c usmart_config.c usmart_str.c
  group README
    ../: README.TXT
  group LWIP/api
    ../LWIP/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group LWIP/core
    ../LWIP/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../LWIP/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group LWIP/netif
    ../LWIP/netif/: bridgeif.c ethernet.c lowpan6.c lowpan6_ble.c lowpan6_common.c zepif.c
  group LWIP/arch
    ../LWIP/arch/: ethernetif.c
  group LWIP/My_demo
    ../LWIP/My_demo/src/: udpecho.c
